Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 0001
Time: 2024-12-23T10:12:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 23 10:12:58 2024 * Host: LIS-C-001JH * Database: C:\Users\MEJ3OVR\AppData\Local\Temp\f9838461-8c9a-418b-bdd8-42058f842667\44cba395-93d0-4029-8fca-807b1f34a0a3\ifc * Database version: 5507 * Database creation date: Mon Dec 23 10:12:57 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 23 10:12:58 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 23 10:12:58 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​:Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​, Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​:Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​:348415
In: Level 1
Type - Material: Body Black
Type - Constraints - Crypt_OSDP: no; Default Elevation: 1400 mm
Type - Dimensions - Dimension depth (mm): 24; Dimension height (mm): 81; Dimension width (mm): 81
Type - Electrical - Operating voltage (VDC) (maximum): 30; Operating voltage (VDC) (minimum): 8; Power consumption (VA): 1.70
Type - General - IP Class: IP54; Operating temperature (°C) (maximum): 60; Operating temperature (°C) (minimum): -25
Type - Identity Data - Description: The LECTUS select E line consists of two different reader variants, one with keypad and one without keypad. The series is available in white or black color with a silver frame. The readers can be flush-; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_select_E_Installation_Manual_enUS_128432021003.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: N/A; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LECTUS_select_E_Data_sheet_enUS_128430959371.pdf; Product Website: https://commerce.boschsecurity.com/us/en/LECTUS-select-E/p/F.01U.426.544/; Type Name: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​
Type - Materials and Finishes - Color: Black/silver; Color in RAL: N/A
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​
Type - Pset_BuildingElementProxyCommon - Reference: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Material: Body Black, Body_Silver
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Schedule Level: Level: Level 1
Construction - ARA-ESELECT-GWA Wallmount box silver,LECTsel.E: no; ARA-ESELECT-WWA Wallmount box white,LECT.sel.E: yes; ARA-OSDP-RES Config card, Select E, reset: yes
Dimensions - Area: 0.0169378 m2; Volume: 0.000156949 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Identity Data - CTN: ARA-ESELECT-WWA & ARA-OSDP-RES & ARD-ESELECT-BOK​; Mark: 2; Material number: F.01U.427.708 & F.01U.426.905 & F.01U.426.544​
Other - Family: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​; Family and Type: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​; Type: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​; Type Id: Intrusion-Products_Bosch_Reader E, OSDP, keypad, black​ _ARD-ESELECT-BOK​: Reader E, OSDP, keypad, black​_ARD-ESELECT-BOK​
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_348415
Description: Flow; FlowDirection: SOURCEANDSINK
