Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 0001
Time: 2024-12-23T10:19:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.30.74 - Exporter 21.1.30.74 - Alternate UI 21.1.30.74
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 23 10:19:03 2024 * Host: LIS-C-001JH * Database: C:\Users\MEJ3OVR\AppData\Local\Temp\f9838461-8c9a-418b-bdd8-42058f842667\28fd2c97-d37d-484a-b4c1-e758fbdda7ed\ifc * Database version: 5507 * Database creation date: Mon Dec 23 10:19:02 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 23 10:19:02 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 23 10:19:02 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA:Wallmount box, gray_ARA-ESELECT-GWA, Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA:Wallmount box, gray_ARA-ESELECT-GWA:351171
In: Level 1
Type - Material: Body_Grey
Type - Constraints - Crypt_OSDP: no; Default Elevation: 1400 mm
Type - Dimensions - Dimension depth (mm): 25; Dimension height (mm): 81; Dimension width (mm): 81
Type - Identity Data - Description: N/A; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: N/A; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: N/A; Product Information: N/A; Product Website: https://commerce.boschsecurity.com/nordics/en/Wallmount-box-gray/p/F.01U.428.680/; Type Name: Wallmount box, gray_ARA-ESELECT-GWA
Type - Materials and Finishes - Color: White; Color in RAL: N/A
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA
Type - Pset_BuildingElementProxyCommon - Reference: Wallmount box, gray_ARA-ESELECT-GWA; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: Wallmount box, gray_ARA-ESELECT-GWA
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Schedule Level: Level: Level 1
Dimensions - Area: 0.0172174 m2; Volume: 0.0000325224 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Identity Data - CTN: ARA-ESELECT-GWA; Mark: 5; Material number: F.01U.428.680
Other - Family: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA: Wallmount box, gray_ARA-ESELECT-GWA; Family and Type: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA: Wallmount box, gray_ARA-ESELECT-GWA; Type: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA: Wallmount box, gray_ARA-ESELECT-GWA; Type Id: Intrusion-Products_Bosch_Wallmount box, gray_ARA-ESELECT-GWA: Wallmount box, gray_ARA-ESELECT-GWA
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_351171
Description: Flow; FlowDirection: SOURCEANDSINK
